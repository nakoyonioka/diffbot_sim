Commit message: cleanup

File: urdf/robot.xacro.urdf (robot description, URDF)
Before this commit: robot diffbot, 11 links, 10 joints
Links:
- removed link spray_link
Joints:
- removed joint spray_joint
